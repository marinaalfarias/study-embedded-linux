## br2-external/package/contador/Config.in
```kconfig
config BR2_PACKAGE_CONTADOR
    bool "contador"
    help
      Contador simples para RISC-V
```
